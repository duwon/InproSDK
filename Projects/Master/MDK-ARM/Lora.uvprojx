# Keil uVision project Lora.uvprojx, settings and files
target Master (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IROM(0x08000000,0x00030000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Broadcast +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L072xx, USE_B_L072Z_LRWAN1,USE_HAL_DRIVER MASTER_MODE
  c misc: --C99
  c include: ..\inc;..\inc;..\..\..\Drivers\BSP\INPRO_LORAWAN;..\..\..\Drivers\BSP\CMWX1ZZABZ-0xx;..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\Drivers\CMSIS\Include;..\..\..\Middlewares\Third_Party\LoRaWAN\Crypto;..\..\..\Middlewares\Third_Party\LoRaWAN\Mac;..\..\..\Middlewares\Third_Party\LoRaWAN\Phy;..\..\..\Middlewares\Third_Party\LoRaWAN\Utilities;..\..\..\Drivers\BSP\X_NUCLEO_IKS01A2;..\..\..\Drivers\BSP\Components\Common;..\..\..\Drivers\BSP\Components\hts221;..\..\..\Drivers\BSP\Components\lps25hb;..\..\..\Drivers\BSP\Components\sx1276;..\..\..\Middlewares\Third_Party\LoRaWAN\Core;..\..\..\Middlewares\DW;..\..\..\Drivers\BSP\Components\lps22hb;..\usb;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Drivers/BSP/Components
    ../../../Drivers/BSP/Components/sx1276/: sx1276.c
    ../../../Drivers/BSP/X_NUCLEO_IKS01A2/: x_nucleo_iks01a2.c x_nucleo_iks01a2_humidity.c x_nucleo_iks01a2_temperature.c
    ../../../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    ../../../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
  group Drivers/BSP/CMWX1ZZABZ-0xx
    ../../../Drivers/BSP/CMWX1ZZABZ-0xx/: mlm32l07x01.c
  group Drivers/BSP/INPRO_LORAWAN
    ../../../Drivers/BSP/INPRO_LORAWAN/: inproRev2.c
  group Drivers/CMSIS
    ../../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_spi.c stm32l0xx_hal_uart.c stm32l0xx_hal_adc.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_i2c.c stm32l0xx_ll_usb.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c
  group Drivers/USB
    ../usb/: usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group Middlewares/USB
    ../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/LoRaWAN/Utilities
    ../../../Middlewares/Third_Party/LoRaWAN/Utilities/: low_power_manager.c timeServer.c utilities.c queue.c trace.c
  group Projects/MDK-ARM
    ./: startup_stm32l072xx.s
  group Projects/Master
    ../src/: debug.c hw_gpio.c hw_rtc.c hw_spi.c main.c vcom.c mlm32l0xx_hal_msp.c mlm32l0xx_it.c mlm32l0xx_hw.c bsp.c
  group Projects/DW
    ../../../Middlewares/DW/: LoraMessage.c LoraRadio.c PayloadMessage.c
  group Projects/Message
    ../src/: message.c
